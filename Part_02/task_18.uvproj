# Keil uVision project task_18.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: task_18 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 24c02.c 24c02.h i2c.c i2c.h lcd.c lcd.h
